# Keil uVision project K1986BE92QI_by_NR.electronics.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.51
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: K1986BE92QI_by_NR.electronics +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS\CM3\CoreSupport;.\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;.\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;.\Config;.\MDR32F9Qx_StdPeriph_Driver\inc;.\MDR32F9Qx_StdPeriph_Driver\inc\USB_Library;.\MDR32F9Qx_StdPeriph_Driver\src;.\MDR32F9Qx_StdPeriph_Driver\src\USB_Library;..\K1986BE92QI;.\RTE
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./: main.c
  group CMSIS
    ./CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h stdint.h
    ./CMSIS/CM3/DeviceSupport/MDR32F9Qx/inc/: MDR32Fx.h
    ./CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/arm/: system_MDR32F9Qx.c system_MDR32F9Qx.h startup_MDR32F9Qx.s
  group StdPeriph
    ./MDR32F9Qx_StdPeriph_Driver/inc/: MDR32F9Qx_adc.h MDR32F9Qx_audio.h MDR32F9Qx_bkp.h MDR32F9Qx_can.h MDR32F9Qx_comp.h MDR32F9Qx_dac.h MDR32F9Qx_dma.h MDR32F9Qx_ebc.h MDR32F9Qx_eeprom.h MDR32F9Qx_i2c.h MDR32F9Qx_iwdg.h MDR32F9Qx_keypad.h MDR32F9Qx_led.h MDR32F9Qx_lib.h MDR32F9Qx_port.h MDR32F9Qx_power.h MDR32F9Qx_rst_clk.h MDR32F9Qx_ssp.h MDR32F9Qx_timer.h MDR32F9Qx_uart.h MDR32F9Qx_usb.h MDR32F9Qx_wwdg.h
    ./MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_adc.c MDR32F9Qx_audio.c MDR32F9Qx_bkp.c MDR32F9Qx_can.c MDR32F9Qx_comp.c MDR32F9Qx_dac.c MDR32F9Qx_dma.c MDR32F9Qx_ebc.c MDR32F9Qx_eeprom.c MDR32F9Qx_i2c.c MDR32F9Qx_iwdg.c MDR32F9Qx_keypad.c MDR32F9Qx_led.c MDR32F9Qx_port.c MDR32F9Qx_power.c MDR32F9Qx_rst_clk.c MDR32F9Qx_ssp.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c MDR32F9Qx_usb.c MDR32F9Qx_wwdg.c
software components: CMSIS:CORE 5.2.0
